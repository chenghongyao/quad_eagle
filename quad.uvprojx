# Keil uVision project quad.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quad
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user\include;.\lib\include;.\software\include;.\driver\table;.\driver\esp8266;.\driver\hmc5883;.\driver\led;.\driver\motor;.\driver\mpu6050;.\driver\ms5611;.\driver\NRF24L01;.\driver\table;.\driver\ultrasound;.\driver\ccd;.\driver\eagle
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/src/: delay.c lolv.c main.c sys.c
  group lib
    ./lib/src/: iap.c flash.c myiic.c lib_helper.c usart.c adc.c sccb.c
  group driver
    ./driver/eagle/: eagle.c
    ./driver/NRF24L01/: nrf.c
    ./driver/table/: table.c
    ./driver/led/: led.c
  group software
    ./software/src/: bytes.c cmath.c queue.c wos.c key.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
